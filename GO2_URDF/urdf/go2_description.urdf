Commit message: changed meshes file directory

File: GO2_URDF/urdf/go2_description.urdf (robot description, URDF)
Before this commit: robot go2_description, 29 links, 28 joints
Links:
- link base: geometry collision box size=0.3762 0.0935 0.114; visual mesh filename=package://GO2_URDF/dae/base.dae
